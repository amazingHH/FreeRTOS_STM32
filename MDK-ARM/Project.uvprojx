# Keil uVision project Project.uvprojx, settings and files
target STM32F4xx-Nucleo (6210000::V6.21::ARMCLANG)
  device: STM32F401VEHx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x20017FFF) IROM(0x08000000-0x0807FFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: STM32F4xx-Nucleo
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F401xE,USE_STM32F4XX_NUCLEO
  c misc: -xc -std=c99
  c include: ..\Inc;..\..\..\..\..\..\Drivers\CMSIS\Device\ST\STM32F4xx\Include;..\..\..\..\..\..\Drivers\STM32F4xx_HAL_Driver\Inc;..\..\..\..\..\..\Drivers\BSP\STM32F4xx-Nucleo;..\FreeRTOS\include;..\FreeRTOS\port\GCC\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x18000
  link misc: --diag_suppress=L6329
  group Drivers/BSP/STM32F4xx-Nucleo
    ../../../../../../Drivers/BSP/STM32F4xx-Nucleo/: stm32f4xx_nucleo.c
  group Doc
    ../: readme.txt
  group Drivers/STM32F4xx_HAL_Driver
    ../../../../../../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_spi.c stm32f4xx_hal_dma.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_rcc.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_adc.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal_tim.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_gpio.c
  group Example/MDK-ARM
    ./: startup_stm32f401xe.s
  group Example/User
    ../Src/: stm32f4xx_it.c stm32f4xx_hal_msp.c main.c flash.c ParTest.c
  group Drivers/CMSIS
    ../Src/: system_stm32f4xx.c
  group FreeRTOS/src
    ../FreeRTOS/src/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ../FreeRTOS/port/MemMang/: heap_4.c
    ../FreeRTOS/port/GCC/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.6.0
